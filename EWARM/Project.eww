<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\sensor_pulse_watch_water.ewp</path>
  </project>
  <batchBuild />
</workspace>
